# Keil uVision project spray.uvproj, settings and files
target Target 1 (MCS-51)
  device: MS51xB9xE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: spray
  c flags: Optimize=9
  c define: FOSC_240000
  c include: .\Device\Include;.\StdDriver\inc;.\RTX Tiny2\inc;.\TM1650;.\Application
  group StartUp
    ./: MS51_STARTUP.A51
    ../spray/RTXTiny2/: Conf_tny.A51
  group Application
    ./: main.c hardware.c business.c
    ./Application/: I2C_GPIO.c button.c systick.c output.c nv.c
    ./TM1650/: tm11650.c
  group StdPeripheral
    ./StdDriver/src/: sys.c eeprom.c
    ../spray - v6/StdDriver/src/: common.c
