# Keil uVision project new.uvproj, settings and files
target Target 1 (MCS-51)
  device: Nexar TSK51 Altium
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF) CLOCK(44000000)
  output: new
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 fifo.cpp
  group New Group
    ./: fifo.c
